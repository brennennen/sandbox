FILESEXTRAPATHS:prepend := "${THISDIR}:"
SRC_URI += "file://0001-add-i2c5-dts.patch;md5sum=7b34a219b376613ce596be326087612f"
